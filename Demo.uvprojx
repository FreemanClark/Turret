# Keil uVision project Demo.uvprojx, settings and files
target LPC1768 Flash (6190000::V6.19::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=2 v6Lang=1 v6LangP=5
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Files
    ./: main.c try.s
software components: CMSIS:CORE 5.6.0, Board Support:Graphic LCD 1.0.0, CMSIS Driver:SPI:SSP 2.10.0, Device:GPDMA 1.4.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
